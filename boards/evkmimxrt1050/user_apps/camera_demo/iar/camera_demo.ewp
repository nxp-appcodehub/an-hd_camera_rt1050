# IAR project camera_demo.ewp, settings and files
configuration sdram_txt (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6A; SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  ICCARM.CCDiagSuppress: Pa082,Pa089,Pe188
  ICCARM.CCIncludePath2: ..\src; ..\src\board; ..\src\camera; ..\src\touch; ..\..\..\..\..\devices\MIMXRT1052; ..\..\..\..\..\devices\MIMXRT1052\drivers; ..\..\..\..\..\devices\MIMXRT1052\utilities; ..\..\..\..\..\devices\MIMXRT1052\utilities\io; ..\..\..\..\..\devices\MIMXRT1052\utilities\log; ..\..\..\..\..\devices\MIMXRT1052\utilities\str; ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\middleware\fatfs\src; ..\..\..\..\..\middleware\fatfs\src\fsl_sd_disk; ..\..\..\..\..\middleware\libjpeg\inc; ..\..\..\..\..\middleware\sdmmc\inc; ..\..\..\..\..\middleware\sdmmc\port
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: camera_demo.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram_txt.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6A; SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; XIP_EXTERNAL_FLASH
  OBJCOPY.OOCOutputFile: camera_demo.bin
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_pxp.c fsl_pxp.h fsl_usdhc.c fsl_usdhc.h
  group middleware/fatfs
    ../../../../../middleware/fatfs/src/: diskio.c diskio.h ff.c ff.h integer.h
  group middleware/fatfs/fsl_sd_disk
    ../../../../../middleware/fatfs/src/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group middleware/fatfs/option
    ../../../../../middleware/fatfs/src/option/: unicode.c
  group middleware/libjpeg/inc
    ../../../../../middleware/libjpeg/inc/: cderror.h cdjpeg.h jdct.h jerror.h jinclude.h jmemsys.h jmorecfg.h jpegint.h jpeglib.h jversion.h transupp.h
  group middleware/libjpeg/src
    ../../../../../middleware/libjpeg/src/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group middleware/sdmmc/inc
    ../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group middleware/sdmmc/port
    ../../../../../middleware/sdmmc/port/usdhc/interrupt/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../../../../middleware/sdmmc/port/: fsl_sdmmc_event.h
  group middleware/sdmmc/src
    ../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group source
    ../src/: ffconf.h jconfig.h main.c
  group source/board
    ../src/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group source/camera
    ../src/camera/: fsl_camera.h fsl_camera_device.h fsl_camera_receiver.h fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h fsl_mt9m114.c fsl_mt9m114.h fsl_video_common.h
  group source/touch
    ../src/touch/: fsl_ft5406.c fsl_ft5406.h
  group startup
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
    ../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
